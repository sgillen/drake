Commit message: Hack in camera

File: drake/examples/kuka_iiwa_arm/models/cameras/asus_xtion.urdf (robot description, URDF)
Before this commit: robot asus_xtion, 1 links, 0 joints
Links:
- link base_link: geometry visual mesh filename=asus_xtion.obj
